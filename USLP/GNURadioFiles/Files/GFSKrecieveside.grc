options:
  parameters:
    generate_options: qt_gui
    id: new_hier
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fd
  id: variable
  parameters:
    value: h*symbols_per_second/2
  states: {}
- name: h
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: symbols_per_second
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/charliewang/Downloads/GFSKtest.bin
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '00000110101111100100010100000110'
    threshold: '3'
    type: byte
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '8'
    sensitivity: math.pi*0.5/8
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: int(samp_rate/symbols_per_second)
    sensitivity: 2*math.pi*fd/samp_rate
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(round(samp_rate / (8*symbols_per_second)))
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 150e3, 100e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '5000'
    src_zeros: 'False'
    type: byte
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 440e6
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '256'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '512'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 440e6
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 440e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 440e6
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: vocoder_alaw_decode_bs_0
  id: vocoder_alaw_decode_bs
  parameters: {}
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_1, '0', digital_gfsk_demod_0, '0']
- [blocks_throttle2_2, '0', blocks_char_to_float_0, '0']
- [blocks_throttle2_2, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_throttle2_2, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_gfsk_mod_0, '0', blocks_throttle2_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_gfsk_demod_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [network_udp_source_0, '0', digital_gfsk_mod_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
