options:
  parameters:
    generate_options: qt_gui
    id: USLP_DSP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Df
  id: variable
  parameters:
    value: int(Fraction(SPS*Rs/(samp_rate/decim_0)).limit_denominator(1000).denominator)
  states: {}
- name: Uf
  id: variable
  parameters:
    value: int(Fraction(SPS*Rs/(samp_rate/decim_0)).limit_denominator(1000).numerator)
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(decim_0)
  states: {}
- name: decim_0
  id: variable
  parameters:
    value: max(1, math.floor(samp_rate/(2*Rs)))
  states: {}
- name: qpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '51200'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 15e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[1+1j, -1+1j,-1-1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: BW
  id: parameter
  parameters:
    value: 6.55e6
  states: {}
- name: FFC
  id: parameter
  parameters:
    value: '2733267.170109161'
  states: {}
- name: Rs
  id: parameter
  parameters:
    label: Symbol Rate
    type: eng_float
    value: '5533362.833208721'
  states: {}
- name: SPS
  id: parameter
  parameters:
    value: '4'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/(samples_per_symbol*4)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: FFC
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: FFC
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Administrator\Pictures\4Present\Dem_4P_gnu\qBits
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Administrator\Pictures\4Present\Dem_4P_gnu\gnu_p_25May17\gnu_p\QPSK_15M_.iq
    repeat: 'False'
    type: short
    vlen: '2'
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'True'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 0, 0, 1, 0, 1, 0)
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1 + 1j, 1 - 1j, -1 + 1j, -1-1j]'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: samples_per_symbol
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pi/10000
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '0.2'
    loop_bw: pi/10000.0
    max_dev: '0.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: '4'
    ted_gain: '0.0125'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: 11*samples_per_symbol
    samp_rate: samp_rate
    sym_rate: samp_rate/samples_per_symbol
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '5'
    cutoff_freq: BW/2
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: BW/2+BW/20
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '1024'
    port: '5000'
    src_zeros: 'False'
    type: byte
  states: {}
- name: pi
  id: parameter
  parameters:
    value: '3.14159265358979'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.1'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '4096'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.50'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '256'
    srate: samp_rate
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    size: '32'
    srate: samp_rate
    type: float
    update_time: '0.50'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Df
    interp: Uf
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_complex_to_real_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_divide_xx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_float_to_complex_0_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0, '0']
- [blocks_rms_xx_0, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_char_to_float_1, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_constellation_modulator_0, '0', filter_fft_rrc_filter_0, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [filter_fft_rrc_filter_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [network_udp_source_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0, '0', blocks_divide_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_rms_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
