options:
  parameters:
    generate_options: qt_gui
    id: USLP_DSP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: qpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '51200'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/(samples_per_symbol*4)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 0, 0, 1, 0, 1, 0)
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1 + 1j, 1 - 1j, -1 + 1j, -1-1j]'
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: samples_per_symbol
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: 11*samples_per_symbol
    samp_rate: samp_rate
    sym_rate: samp_rate/samples_per_symbol
    type: ccc
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '1024'
    port: '5000'
    src_zeros: 'False'
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.50'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '256'
    srate: samp_rate
    type: complex
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    size: '32'
    srate: samp_rate
    type: float
    update_time: '0.50'
  states: {state: disabled}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_complex_to_real_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_char_to_float_1, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', filter_fft_rrc_filter_0, '0']
- [filter_fft_rrc_filter_0, '0', blocks_multiply_xx_0, '0']
- [network_udp_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
